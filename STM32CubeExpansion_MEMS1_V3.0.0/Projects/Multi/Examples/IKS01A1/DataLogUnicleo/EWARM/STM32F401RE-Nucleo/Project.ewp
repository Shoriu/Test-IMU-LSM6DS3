# IAR project Project.ewp, settings and files
configuration STM32F4xx-Nucleo (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE; USE_STM32F4XX_NUCLEO
  ICCARM.CCIncludePath2: ..\..\Inc; ..\..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include; ..\..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc; ..\..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo; ..\..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A1; ..\..\..\..\..\..\..\Drivers\BSP\Components\Common; ..\..\..\..\..\..\..\Drivers\BSP\Components\hts221; ..\..\..\..\..\..\..\Drivers\BSP\Components\lis3mdl; ..\..\..\..\..\..\..\Drivers\BSP\Components\lps25hb; ..\..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds0; ..\..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds3; ..\..\..\..\..\..\..\Drivers\BSP\Components\lps22hb; ..\..\..\..\..\..\..\Drivers\CMSIS\Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\Inc
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f401xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Drivers/BSP/Components
    ../../../../../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../../../../../../../Drivers/BSP/Components/lis3mdl/: LIS3MDL_MAG_driver.c LIS3MDL_MAG_driver_HL.c
    ../../../../../../../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    ../../../../../../../Drivers/BSP/Components/lps25hb/: LPS25HB_Driver.c LPS25HB_Driver_HL.c
    ../../../../../../../Drivers/BSP/Components/lsm6ds0/: LSM6DS0_ACC_GYRO_driver.c LSM6DS0_ACC_GYRO_driver_HL.c
    ../../../../../../../Drivers/BSP/Components/lsm6ds3/: LSM6DS3_ACC_GYRO_driver.c LSM6DS3_ACC_GYRO_driver_HL.c
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Drivers/BSP/X_NUCLEO_IKS01A1
    ../../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1/: x_nucleo_iks01a1.c x_nucleo_iks01a1_accelero.c x_nucleo_iks01a1_gyro.c x_nucleo_iks01a1_humidity.c x_nucleo_iks01a1_magneto.c x_nucleo_iks01a1_pressure.c x_nucleo_iks01a1_temperature.c
  group Drivers/CMSIS
    ../../Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_uart.c
  group Example/EWARM
    ./: startup_stm32f401xe.s
  group Example/User
    ../../Src/: com.c cube_hal_f4.c DemoSerial.c main.c sensor_commands.c serial_protocol.c stm32f4xx_hal_msp.c stm32f4xx_it.c
